## boards/shields/krankboard/Kconfig.shield
```kconfig
# No whitespace after the comma or in your part name!
config SHIELD_KRANKBOARDL
    def_bool $(shields_list_contains,krankboardL)
```
